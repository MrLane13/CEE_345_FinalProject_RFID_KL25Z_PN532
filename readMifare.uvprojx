# Keil uVision project readMifare.uvprojx, settings and files
target readMifare (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.10.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: readMifare
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: TARGET_FF_ARDUINO, TARGET_KLXX, TARGET_KL25Z, TARGET_CORTEX_M, TARGET_LIKE_MBED, TARGET_M0P, TARGET_Freescale, TOOLCHAIN_ARM_STD, __MBED__=1, MBED_BUILD_TIMESTAMP=1460680426, __CORTEX_M0PLUS, TOOLCHAIN_ARM, TARGET_LIKE_CORTEX_M0, ARM_MATH_CM0PLUS, __ASSERT_MSG
  c misc: --gnu --no_rtti
  c include: .; PN532; mbed; mbed/TARGET_KL25Z; mbed/TARGET_KL25Z/TARGET_Freescale; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z; mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD
  asm define: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  group Include Files
    PN532/: Adafruit_PN532.h
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_KL25Z/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h MKL25Z4.h system_MKL25Z4.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/: clk_freqs.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/: device.h PeripheralNames.h PinNames.h
  group Source Files
    PN532/: Adafruit_PN532.cpp
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar mbed_overrides.o retarget.o startup_MKL25Z4.o sys.o system_MKL25Z4.o
    ./: main.cpp
    ./: cardcheck.cpp delay.cpp blinkLED.cpp
software components: CMSIS:CORE 4.3.0
